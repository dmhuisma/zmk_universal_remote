// Portrait UI on the 170x320 panel.
//
// Every screen is built the same way, so there is one thing to learn:
//
//   - A thin status bar across the top: the screen's name on the left, the
//     battery and the wireless link on the right.
//   - The screen's buttons in the middle. Every screen fits without
//     scrolling, so nothing is ever hidden below the edge.
//   - Navigation along the bottom, always in the same place under the thumb.
//     The four main screens (Home, Lights, TV, More) share a tab bar. The
//     screens opened from them (Climate, Rosie, Chester, Touchpad) swap the
//     tab bar for one wide Back button (on the Touchpad screen, Back and
//     the Tilt toggle).
//
// Home holds the whole-house scenes and is the screen the remote wakes to.
// More opens Climate and the two vacuums, and holds the remote's own screen
// brightness. TV's Mouse row opens the Touchpad screen (titled Mouse), which
// moves the host's mouse pointer (src/touchpad.c).
//
// Buttons come in a few shapes, each used the same way everywhere:
//   - Tiles (half width): a coloured icon over a short label.
//   - Rows (full width): an icon in a tinted circle, then a label. A row with
//     a chevron (>) opens another screen; one without it is sent.
//   - Room keys (vacuum screens): text only, since every one would have the
//     same icon.
// Colours follow what a button controls: amber for lights, violet for
// scenes, blue for TV, orange and cyan for warmer and cooler, green for the
// vacuums.
//
// Home Assistant cannot send state back to the remote, so every control is a
// stateless command button: buttons show what they do, not whether a light
// is on. Each action button is sent over BTHome by src/bthome.c; see the
// bthome-buttons list at the end of this file, home_assistant/
// bthome_buttons.yaml and tools/gen_hass_automation.py. Navigation buttons
// (tabs, rows with a chevron, Back), the brightness keys and the Touchpad
// screen's Tilt toggle are not sent.

#include "ui_icons.h"

#define UI_WIDTH 170
#define UI_HEIGHT 320

// The status bar and the bottom navigation bar, and the area between them.
#define UI_STATUS_HEIGHT 24
#define UI_NAVBAR_HEIGHT 54
#define UI_CONTENT_HEIGHT (UI_HEIGHT - UI_STATUS_HEIGHT - UI_NAVBAR_HEIGHT)

// The space at the screen's sides, and between buttons. Content sits a
// little closer to the status bar than to the navigation bar, which carries
// its own padding.
#define UI_GUTTER 8
#define UI_GAP 6
#define UI_CONTENT_PAD_TOP 4
#define UI_CONTENT_PAD_BOTTOM 6

// A caption over a group of buttons: 15 px of text with room above it to
// set the group apart from the one before.
#define UI_CAPTION_HEIGHT 20
// A full-width row on the More screen, and the row that opens the Touchpad.
#define UI_ROW_HEIGHT 48
// The TV screen's row of round media keys.
#define UI_TV_MEDIA_HEIGHT 48
// An icon in a tinted circle at the left of a row, and where the row's label
// starts after it.
#define UI_ROW_ICON_INSET 8
#define UI_ROW_TEXT_INSET 52
#define UI_ROW_CHEVRON_INSET 0

// Corner radii. LVGL clamps a radius to half an element's shorter side, so
// UI_RADIUS_FULL makes a pill, or a circle of a square.
#define UI_RADIUS 14
#define UI_RADIUS_FULL 0x7fff

// The palette: a near-black ground, cool grey surfaces that step lighter
// with elevation, and one accent per kind of thing a button controls. Each
// accent has a dark tint of itself for the circle behind an icon.
#define UI_COLOR_BACKGROUND 0x0b0c10
#define UI_COLOR_BAR 0x15171d
#define UI_COLOR_TILE 0x1f2229
#define UI_COLOR_TILE_PRESSED 0x3d5c94
#define UI_COLOR_TRACK 0x343844
#define UI_COLOR_TEXT 0xf1f3f7
#define UI_COLOR_TEXT_SECONDARY 0xa3a9b7
#define UI_COLOR_TEXT_TERTIARY 0x6b7180
#define UI_COLOR_NEUTRAL_TINT 0x30343e

#define UI_COLOR_BLUE 0x8ab4ff
#define UI_COLOR_BLUE_TINT 0x1f3354
#define UI_COLOR_AMBER 0xffc861
#define UI_COLOR_AMBER_TINT 0x3b3017
#define UI_COLOR_VIOLET 0xc3a6ff
#define UI_COLOR_VIOLET_TINT 0x2e2548
#define UI_COLOR_ORANGE 0xffa36b
#define UI_COLOR_ORANGE_TINT 0x3e2618
#define UI_COLOR_CYAN 0x74d7f7
#define UI_COLOR_CYAN_TINT 0x153544
#define UI_COLOR_GREEN 0x7de3a3
#define UI_COLOR_GREEN_TINT 0x163b26

// Filled buttons: Clean all, and Play/Pause.
#define UI_COLOR_GO 0x1f6b40
#define UI_COLOR_ON_GO 0xe2fbea
#define UI_COLOR_PLAY 0x3a68c2
#define UI_COLOR_ON_PLAY 0xffffff

#define UI_STRINGIFY_(x) #x
#define UI_STRINGIFY(x) UI_STRINGIFY_(x)

#define UI_STYLE(style) <&style DT_LVGL_PART_MAIN DT_LVGL_STATE_DEFAULT>

// A style used both normally and while pressed, so a filled button keeps
// its own colour when pressed (the theme's darkening still shows the press)
// instead of taking the pressed colour of plain buttons.
#define UI_STYLE_KEEP_PRESSED(style)                                           \
    <&style DT_LVGL_PART_MAIN DT_LVGL_STATE_DEFAULT>,                          \
    <&style DT_LVGL_PART_MAIN DT_LVGL_STATE_PRESSED>

#define UI_GRID_FR DT_LVGL_GRID_FR(1)

// ---------------------------------------------------------------------------
// Screen furniture
// ---------------------------------------------------------------------------

// dt-lvgl has no top layer, so each screen carries its own copy of the status
// bar. src/ui_status.c updates every copy's wireless icon (ui-wireless-icons)
// and UI_BATTERY_STATUS every copy's battery level. The title takes the
// space the battery and wireless icon leave.
#define UI_STATUS_BAR(name, title)                                             \
    name##_status_bar {                                                        \
        compatible = "dt-lvgl-container";                                      \
        pos = <0 0>;                                                           \
        width-pct = <100>;                                                     \
        height = <UI_STATUS_HEIGHT>;                                           \
        not-scrollable;                                                        \
        layout = "flex";                                                       \
        flex-flow = "row";                                                     \
        flex-cross-place = "center";                                           \
        flex-track-place = "center";                                           \
        styles = UI_STYLE(ui_status_bar_style);                                \
                                                                               \
        name##_title {                                                         \
            compatible = "dt-lvgl-label";                                      \
            text = title;                                                      \
            flex-grow = <1>;                                                   \
            styles = UI_STYLE(ui_status_title_style);                          \
        };                                                                     \
                                                                               \
        name##_battery_label: name##_battery_label {                           \
            compatible = "dt-lvgl-label";                                      \
            text = "";                                                         \
            styles = UI_STYLE(ui_status_text_style);                           \
        };                                                                     \
                                                                               \
        /* LV_SYMBOL_WIFI. Dimmed until connected. */                          \
        name##_wireless_icon: name##_wireless_icon {                           \
            compatible = "dt-lvgl-label";                                      \
            text = "\xef\x87\xab";                                             \
            disabled;                                                          \
            styles = <&ui_status_text_style DT_LVGL_PART_MAIN DT_LVGL_STATE_DEFAULT>, \
                     <&ui_status_dim_style DT_LVGL_PART_MAIN DT_LVGL_STATE_DISABLED>; \
        };                                                                     \
    };

#define UI_BATTERY_STATUS(name)                                                \
    name##_battery_status {                                                    \
        compatible = "dt-lvgl-zmk-battery-label";                              \
        target = <&name##_battery_label>;                                      \
    };

// The area between the status bar and the navigation bar, laid out as a
// grid. Every page fits, so none scrolls.
#define UI_PAGE_PROPS(page_columns, page_rows)                                 \
    compatible = "dt-lvgl-container";                                          \
    pos = <0 UI_STATUS_HEIGHT>;                                                \
    width-pct = <100>;                                                         \
    height = <UI_CONTENT_HEIGHT>;                                              \
    not-scrollable;                                                            \
    layout = "grid";                                                           \
    grid-columns = page_columns;                                               \
    grid-rows = page_rows;                                                     \
    styles = UI_STYLE(ui_content_style);

#define UI_ONE_COLUMN <UI_GRID_FR>
#define UI_TWO_COLUMNS <UI_GRID_FR UI_GRID_FR>
// Six columns, so a row holds two half-width buttons (span 3) or three
// narrow ones (span 2).
#define UI_SIX_COLUMNS <UI_GRID_FR UI_GRID_FR UI_GRID_FR UI_GRID_FR UI_GRID_FR UI_GRID_FR>

// The bottom bar's own container, which either holds the tabs or Back.
#define UI_NAVBAR_PROPS(bar_columns, bar_style)                                \
    compatible = "dt-lvgl-container";                                          \
    pos = <0 (UI_HEIGHT - UI_NAVBAR_HEIGHT)>;                                  \
    width-pct = <100>;                                                         \
    height = <UI_NAVBAR_HEIGHT>;                                               \
    not-scrollable;                                                            \
    layout = "grid";                                                           \
    grid-columns = bar_columns;                                                \
    grid-rows = <UI_GRID_FR>;                                                  \
    styles = <&ui_navbar_style DT_LVGL_PART_MAIN DT_LVGL_STATE_DEFAULT>,       \
             <&bar_style DT_LVGL_PART_MAIN DT_LVGL_STATE_DEFAULT>;

// The tab for the screen it sits on is drawn checked: its icon sits in a
// lit pill and its label is brighter. Pass on for that tab and off for the
// others.
#define UI_TAB_STATE_on checked;
#define UI_TAB_STATE_off

#define UI_TAB(name, tab, tab_col, icon, tab_text, action, state)              \
    name##_tab_##tab {                                                         \
        compatible = "dt-lvgl-button";                                         \
        grid-cell = <tab_col 0>;                                               \
        grid-align-self-x = "stretch";                                         \
        grid-align-self-y = "stretch";                                         \
        events = <&action DT_LVGL_EVENT_CLICKED>;                              \
        styles = <&ui_tab_style DT_LVGL_PART_MAIN DT_LVGL_STATE_DEFAULT>,      \
                 <&ui_tab_pressed_style DT_LVGL_PART_MAIN DT_LVGL_STATE_PRESSED>, \
                 <&ui_tab_checked_style DT_LVGL_PART_MAIN DT_LVGL_STATE_CHECKED>; \
        UI_TAB_STATE_##state                                                   \
                                                                               \
        name##_tab_##tab##_icon {                                              \
            compatible = "dt-lvgl-label";                                      \
            text = icon;                                                       \
            align = "top-mid";                                                 \
            styles = UI_STYLE(ui_tab_icon_##state##_style);                    \
        };                                                                     \
                                                                               \
        name##_tab_##tab##_label {                                             \
            compatible = "dt-lvgl-label";                                      \
            text = tab_text;                                                   \
            align = "bottom-mid";                                              \
            styles = UI_STYLE(ui_tab_label_style);                             \
        };                                                                     \
    };

#define UI_TAB_BAR(name, home_state, lights_state, tv_state, more_state)       \
    name##_tab_bar {                                                           \
        UI_NAVBAR_PROPS(<UI_GRID_FR UI_GRID_FR UI_GRID_FR UI_GRID_FR>, ui_tab_bar_style) \
                                                                               \
        UI_TAB(name, home, 0, UI_ICON_HOME, "Home", show_home, home_state)     \
        UI_TAB(name, lights, 1, UI_ICON_LIGHTBULB_GROUP, "Lights", show_lights, lights_state) \
        UI_TAB(name, tv, 2, UI_ICON_TELEVISION, "TV", show_tv, tv_state)       \
        UI_TAB(name, more, 3, UI_ICON_DOTS_HORIZONTAL_CIRCLE, "More", show_more, more_state) \
    };

// A pill in the bottom bar: an icon and a label, left-aligned. The Back key
// of UI_BACK_BAR.
#define UI_BAR_KEY_CONTENT(name, icon, key_text, text_inset)                   \
    name##_icon: name##_icon {                                                 \
        compatible = "dt-lvgl-label";                                          \
        text = icon;                                                           \
        align = "left-mid";                                                    \
        styles = UI_STYLE(ui_icon_style);                                      \
    };                                                                         \
                                                                               \
    name##_label {                                                             \
        compatible = "dt-lvgl-label";                                          \
        text = key_text;                                                       \
        align = "left-mid";                                                    \
        align-x = <text_inset>;                                                        \
        styles = UI_STYLE(ui_large_text_style);                                \
    };

#define UI_BACK_KEY(name, key_col, action)                                     \
    name##_back {                                                              \
        compatible = "dt-lvgl-button";                                         \
        grid-cell = <key_col 0>;                                               \
        grid-align-self-x = "stretch";                                         \
        grid-align-self-y = "stretch";                                         \
        events = <&action DT_LVGL_EVENT_CLICKED>;                              \
        styles = UI_STYLE(ui_bar_key_style);                                   \
                                                                               \
        UI_BAR_KEY_CONTENT(name##_back, UI_ICON_ARROW_LEFT, "Back", 29)            \
    };

// The bottom bar of a screen opened from another: one wide Back button that
// returns to it through action.
#define UI_BACK_BAR(name, action)                                              \
    name##_back_bar {                                                          \
        UI_NAVBAR_PROPS(UI_ONE_COLUMN, ui_key_bar_style)                       \
        UI_BACK_KEY(name, 0, action)                                           \
    };

// ---------------------------------------------------------------------------
// Buttons
// ---------------------------------------------------------------------------

#define UI_CELL(cell_col, cell_row, cell_span)                                 \
    grid-cell = <cell_col cell_row>;                                           \
    grid-col-span = <cell_span>;                                               \
    grid-align-self-x = "stretch";                                             \
    grid-align-self-y = "stretch";

// A caption over a group of buttons, spanning caption_span columns.
#define UI_CAPTION(name, caption_col, caption_row, caption_span, caption_text) \
    name {                                                                     \
        compatible = "dt-lvgl-label";                                          \
        text = caption_text;                                                   \
        grid-cell = <caption_col caption_row>;                                 \
        grid-col-span = <caption_span>;                                        \
        grid-align-self-y = "end";                                             \
        styles = UI_STYLE(ui_caption_style);                                   \
    };

// A caption centred over one column of buttons, for side-by-side groups.
#define UI_COLUMN_CAPTION(name, caption_col, caption_row, caption_text)       \
    name {                                                                     \
        compatible = "dt-lvgl-label";                                          \
        text = caption_text;                                                   \
        grid-cell = <caption_col caption_row>;                                 \
        grid-align-self-x = "center";                                          \
        grid-align-self-y = "end";                                             \
        styles = <&ui_caption_style DT_LVGL_PART_MAIN DT_LVGL_STATE_DEFAULT>,  \
                 <&ui_caption_centre_style DT_LVGL_PART_MAIN DT_LVGL_STATE_DEFAULT>; \
    };

// Where a tile's icon and label sit, from its centre: together they make a
// 45 px group in the middle of the tile, however tall the tile is.
#define UI_TILE_ICON_Y (-10)
#define UI_TILE_LABEL_Y 15

// A tile: an accent-coloured icon over a short label. accent picks the
// icon's colour (see UI_ACCENT_STYLES); tile_style is the tile's own look,
// ui_tile_style for most. Half-width tiles leave about 70 px for a label, so
// keep labels to about 9 characters.
#define UI_TILE(name, tile_col, tile_row, tile_span, icon, accent, tile_text, tile_style) \
    name: name {                                                               \
        compatible = "dt-lvgl-button";                                         \
        id = UI_STRINGIFY(name);                                               \
        UI_CELL(tile_col, tile_row, tile_span)                                 \
        styles = UI_STYLE_KEEP_PRESSED(tile_style);                            \
                                                                               \
        name##_icon {                                                          \
            compatible = "dt-lvgl-label";                                      \
            text = icon;                                                       \
            align = "center";                                                  \
            align-y = <UI_TILE_ICON_Y>;                                        \
            styles = UI_STYLE(ui_icon_##accent##_style);                       \
        };                                                                     \
                                                                               \
        name##_label {                                                         \
            compatible = "dt-lvgl-label";                                      \
            text = tile_text;                                                  \
            align = "center";                                                  \
            align-y = <UI_TILE_LABEL_Y>;                                       \
        };                                                                     \
    };

// The inside of a row: the icon in a tinted circle, then the label.
#define UI_ROW_CONTENT(name, icon, accent, row_text, text_style)               \
    name##_icon {                                                              \
        compatible = "dt-lvgl-label";                                          \
        text = icon;                                                           \
        align = "left-mid";                                                    \
        align-x = <UI_ROW_ICON_INSET>;                                         \
        styles = UI_STYLE(ui_badge_##accent##_style);                          \
    };                                                                         \
                                                                               \
    name##_label {                                                             \
        compatible = "dt-lvgl-label";                                          \
        text = row_text;                                                       \
        align = "left-mid";                                                    \
        align-x = <UI_ROW_TEXT_INSET>;                                         \
        styles = UI_STYLE(text_style);                                         \
    };

// A full-width action row, sent like a tile. row_style is the row's own
// look: ui_tile_style, or a filled style for the main action on a screen.
#define UI_ACTION_ROW(name, row_col, row_row, row_span, icon, accent, row_text, row_style) \
    name: name {                                                               \
        compatible = "dt-lvgl-button";                                         \
        id = UI_STRINGIFY(name);                                               \
        UI_CELL(row_col, row_row, row_span)                                    \
        styles = UI_STYLE_KEEP_PRESSED(row_style);                             \
                                                                               \
        UI_ROW_CONTENT(name, icon, accent, row_text, ui_large_text_style)      \
    };

// A full-width row that opens another screen through action. The chevron at
// its right end is what marks a row that goes somewhere.
#define UI_NAV_ROW(name, row_row, icon, accent, row_text, action)              \
    name: name {                                                               \
        compatible = "dt-lvgl-button";                                         \
        id = UI_STRINGIFY(name);                                               \
        UI_CELL(0, row_row, 2)                                                 \
        events = <&action DT_LVGL_EVENT_CLICKED>;                              \
        styles = UI_STYLE(ui_tile_style);                                      \
                                                                               \
        UI_ROW_CONTENT(name, icon, accent, row_text, ui_large_text_style)      \
                                                                               \
        name##_chevron {                                                       \
            compatible = "dt-lvgl-label";                                      \
            text = UI_ICON_CHEVRON_RIGHT;                                      \
            align = "right-mid";                                               \
            align-x = <(-UI_ROW_CHEVRON_INSET)>;                               \
            styles = UI_STYLE(ui_icon_tertiary_style);                         \
        };                                                                     \
    };

// A round key with only an icon, for the media transport buttons.
#define UI_ROUND_KEY(name, key_col, key_row, key_span, icon, key_style, icon_style) \
    name: name {                                                               \
        compatible = "dt-lvgl-button";                                         \
        id = UI_STRINGIFY(name);                                               \
        UI_CELL(key_col, key_row, key_span)                                    \
        styles = UI_STYLE_KEEP_PRESSED(key_style);                             \
                                                                               \
        name##_icon {                                                          \
            compatible = "dt-lvgl-label";                                      \
            text = icon;                                                       \
            align = "center";                                                  \
            styles = UI_STYLE(icon_style);                                     \
        };                                                                     \
    };

// A key with only text: a vacuum's room. Long names wrap onto a second line.
#define UI_TEXT_KEY(name, key_col, key_row, key_text)                          \
    name: name {                                                               \
        compatible = "dt-lvgl-button";                                         \
        id = UI_STRINGIFY(name);                                               \
        UI_CELL(key_col, key_row, 1)                                           \
        styles = UI_STYLE(ui_text_key_style);                                  \
                                                                               \
        name##_label {                                                         \
            compatible = "dt-lvgl-label";                                      \
            text = key_text;                                                   \
            width-pct = <100>;                                                 \
            long-mode = "wrap";                                                \
            align = "center";                                                  \
            styles = UI_STYLE(ui_text_key_label_style);                        \
        };                                                                     \
    };

// A round - or + key at one end of a stepper.
#define UI_STEPPER_KEY(name, key_align, icon)                                  \
    name: name {                                                               \
        compatible = "dt-lvgl-button";                                         \
        id = UI_STRINGIFY(name);                                               \
        width = <UI_STEPPER_KEY_SIZE>;                                         \
        height = <UI_STEPPER_KEY_SIZE>;                                        \
        align = key_align;                                                     \
        styles = UI_STYLE(ui_stepper_key_style);                               \
                                                                               \
        name##_icon {                                                          \
            compatible = "dt-lvgl-label";                                      \
            text = icon;                                                       \
            align = "center";                                                  \
            styles = UI_STYLE(ui_icon_style);                                  \
        };                                                                     \
    };

#define UI_STEPPER_HEIGHT 56
#define UI_STEPPER_PADDING 5
#define UI_STEPPER_KEY_SIZE (UI_STEPPER_HEIGHT - 2 * UI_STEPPER_PADDING)
#define UI_STEPPER_BAR_WIDTH 52
#define UI_STEPPER_BAR_HEIGHT 6

// A full-width card with - and + keys at its ends, and between them a value
// over a level bar. C code handles the keys and sets name_value's text and
// name_bar's value (0-100).
#define UI_STEPPER(name, stepper_row)                                          \
    name {                                                                     \
        compatible = "dt-lvgl-container";                                      \
        UI_CELL(0, stepper_row, 2)                                             \
        not-scrollable;                                                        \
        styles = UI_STYLE(ui_stepper_style);                                   \
                                                                               \
        UI_STEPPER_KEY(name##_down, "left-mid", UI_ICON_MINUS)                 \
                                                                               \
        name##_value: name##_value {                                           \
            compatible = "dt-lvgl-label";                                      \
            text = "";                                                         \
            align = "center";                                                  \
            align-y = <(-6)>;                                                  \
            styles = UI_STYLE(ui_large_text_style);                            \
        };                                                                     \
                                                                               \
        name##_bar: name##_bar {                                               \
            compatible = "dt-lvgl-bar";                                        \
            width = <UI_STEPPER_BAR_WIDTH>;                                    \
            height = <UI_STEPPER_BAR_HEIGHT>;                                  \
            align = "center";                                                  \
            align-y = <12>;                                                    \
            min = <0>;                                                         \
            max = <100>;                                                       \
            value = <0>;                                                       \
            styles = <&ui_level_track_style DT_LVGL_PART_MAIN DT_LVGL_STATE_DEFAULT>, \
                     <&ui_level_fill_style DT_LVGL_PART_INDICATOR DT_LVGL_STATE_DEFAULT>; \
        };                                                                     \
                                                                               \
        UI_STEPPER_KEY(name##_up, "right-mid", UI_ICON_PLUS)                   \
    };

// A vacuum's screen: clean everything, pause, go home, or clean one of four
// rooms. Each room is a node-name suffix and a label; the rooms should match
// the vacuum's map segments in Valetudo.
#define UI_VACUUM_SCREEN(name, title, room_1, room_1_text, room_2, room_2_text, \
                         room_3, room_3_text, room_4, room_4_text)             \
    name##_screen {                                                            \
        compatible = "dt-lvgl-screen";                                         \
        id = UI_STRINGIFY(name);                                               \
        not-scrollable;                                                        \
        styles = UI_STYLE(ui_screen_style);                                    \
                                                                               \
        UI_STATUS_BAR(name, title)                                             \
                                                                               \
        name##_page {                                                          \
            UI_PAGE_PROPS(UI_TWO_COLUMNS,                                      \
                          <UI_ROW_HEIGHT UI_GRID_FR UI_CAPTION_HEIGHT          \
                           UI_VACUUM_ROOM_HEIGHT UI_VACUUM_ROOM_HEIGHT>)       \
                                                                               \
            UI_ACTION_ROW(name##_clean_all, 0, 0, 2, UI_ICON_ROBOT_VACUUM, on_go, \
                          "Clean all", ui_tile_go_style)                       \
            UI_TILE(name##_pause, 0, 1, 1, UI_ICON_PAUSE, plain, "Pause", ui_tile_style) \
            UI_TILE(name##_go_home, 1, 1, 1, UI_ICON_HOME_IMPORT_OUTLINE, green, \
                    "Go home", ui_tile_style)                                  \
            UI_CAPTION(name##_rooms_caption, 0, 2, 2, "Clean one room")        \
            UI_TEXT_KEY(name##_##room_1, 0, 3, room_1_text)                    \
            UI_TEXT_KEY(name##_##room_2, 1, 3, room_2_text)                    \
            UI_TEXT_KEY(name##_##room_3, 0, 4, room_3_text)                    \
            UI_TEXT_KEY(name##_##room_4, 1, 4, room_4_text)                    \
        };                                                                     \
                                                                               \
        UI_BACK_BAR(name, show_more)                                           \
    };

#define UI_VACUUM_ROOM_HEIGHT 44

// ---------------------------------------------------------------------------
// Styles
// ---------------------------------------------------------------------------

// An accent's two icon styles: the icon alone in the accent's colour, for
// tiles, and the icon in a circle of the accent's tint, for rows.
#define UI_ACCENT_STYLES(accent, accent_rgb, tint_rgb)                                  \
    ui_icon_##accent##_style: ui_icon_##accent##_style {                       \
        compatible = "dt-lvgl-style";                                          \
        #dt-lvgl-style-cells = <2>;                                            \
        text-font = <&ui_icon_font>;                                           \
        text-color-hex = <accent_rgb>;                                         \
    };                                                                         \
                                                                               \
    ui_badge_##accent##_style: ui_badge_##accent##_style {                     \
        compatible = "dt-lvgl-style";                                          \
        #dt-lvgl-style-cells = <2>;                                            \
        text-font = <&ui_icon_font>;                                           \
        text-color-hex = <accent_rgb>;                                         \
        bg-color-hex = <tint_rgb>;                                             \
        bg-opa = <255>;                                                        \
        radius = <UI_RADIUS_FULL>;                                             \
        /* The 28 x 27 px glyph box padded out to a 36 px circle. */           \
        pad-left = <4>;                                                        \
        pad-right = <4>;                                                       \
        pad-top = <5>;                                                         \
        pad-bottom = <4>;                                                      \
    };

/ {
    ui_small_font: ui_small_font {
        compatible = "dt-lvgl-font";
        c-symbol = "lv_font_montserrat_12";
    };

    ui_text_font: ui_text_font {
        compatible = "dt-lvgl-font";
        c-symbol = "lv_font_montserrat_14";
    };

    ui_large_font: ui_large_font {
        compatible = "dt-lvgl-font";
        c-symbol = "lv_font_montserrat_16";
    };

    // Material Design Icons, generated by tools/gen_icon_font.sh.
    ui_icon_font: ui_icon_font {
        compatible = "dt-lvgl-font";
        c-symbol = "ui_icons_28";
    };

    ui_screen_style: ui_screen_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-color-hex = <UI_COLOR_BACKGROUND>;
        bg-opa = <255>;
        text-font = <&ui_text_font>;
        text-color-hex = <UI_COLOR_TEXT>;
        pad-top = <0>;
        pad-bottom = <0>;
        pad-left = <0>;
        pad-right = <0>;
    };

    // The status bar sits straight on the screen background.
    ui_status_bar_style: ui_status_bar_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-opa = <0>;
        border-width = <0>;
        radius = <0>;
        pad-top = <0>;
        pad-bottom = <0>;
        pad-left = <(UI_GUTTER + 2)>;
        pad-right = <UI_GUTTER>;
        pad-column = <6>;
    };

    ui_status_title_style: ui_status_title_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        text-font = <&ui_large_font>;
        text-color-hex = <UI_COLOR_TEXT>;
    };

    ui_status_text_style: ui_status_text_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        text-font = <&ui_text_font>;
        text-color-hex = <UI_COLOR_TEXT_SECONDARY>;
    };

    ui_status_dim_style: ui_status_dim_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        text-color-hex = <UI_COLOR_TEXT_TERTIARY>;
        text-opa = <160>;
    };

    // The area between the bars, with the page padding and gaps.
    ui_content_style: ui_content_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-opa = <0>;
        border-width = <0>;
        radius = <0>;
        pad-top = <UI_CONTENT_PAD_TOP>;
        pad-bottom = <UI_CONTENT_PAD_BOTTOM>;
        pad-left = <UI_GUTTER>;
        pad-right = <UI_GUTTER>;
        pad-row = <UI_GAP>;
        pad-column = <UI_GAP>;
    };

    ui_caption_style: ui_caption_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        text-font = <&ui_small_font>;
        text-color-hex = <UI_COLOR_TEXT_SECONDARY>;
        pad-left = <4>;
    };

    ui_caption_centre_style: ui_caption_centre_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        pad-left = <0>;
    };

    ui_large_text_style: ui_large_text_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        text-font = <&ui_large_font>;
    };

    // The bottom bar, a step lighter than the ground.
    ui_navbar_style: ui_navbar_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-color-hex = <UI_COLOR_BAR>;
        bg-opa = <255>;
        border-width = <0>;
        radius = <0>;
        pad-top = <5>;
        pad-bottom = <4>;
    };

    // The tabs share the bar's width with no gap between them, so each label
    // has all of its quarter.
    ui_tab_bar_style: ui_tab_bar_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        pad-left = <2>;
        pad-right = <2>;
        pad-column = <0>;
    };

    // Back, and Tilt beside it, line up with the page's buttons above.
    ui_key_bar_style: ui_key_bar_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        pad-left = <UI_GUTTER>;
        pad-right = <UI_GUTTER>;
        pad-column = <UI_GAP>;
    };

    ui_tab_style: ui_tab_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-opa = <0>;
        border-width = <0>;
        radius = <UI_RADIUS>;
        shadow-width = <0>;
        text-color-hex = <UI_COLOR_TEXT_TERTIARY>;
        pad-top = <0>;
        pad-bottom = <0>;
        pad-left = <0>;
        pad-right = <0>;
    };

    ui_tab_pressed_style: ui_tab_pressed_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-color-hex = <UI_COLOR_TILE>;
        bg-opa = <255>;
    };

    // The pill behind the icon marks the current tab, so this clears the
    // fill LVGL's default theme gives a checked button.
    ui_tab_checked_style: ui_tab_checked_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-opa = <0>;
        text-color-hex = <UI_COLOR_TEXT>;
    };

    // A tab's icon, padded out to the size of the pill drawn behind the
    // current tab's icon.
    ui_tab_icon_off_style: ui_tab_icon_off_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        text-font = <&ui_icon_font>;
        radius = <UI_RADIUS_FULL>;
        pad-top = <1>;
        pad-bottom = <1>;
        pad-left = <6>;
        pad-right = <6>;
    };

    ui_tab_icon_on_style: ui_tab_icon_on_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        text-font = <&ui_icon_font>;
        text-color-hex = <UI_COLOR_BLUE>;
        bg-color-hex = <UI_COLOR_BLUE_TINT>;
        bg-opa = <255>;
        radius = <UI_RADIUS_FULL>;
        pad-top = <1>;
        pad-bottom = <1>;
        pad-left = <6>;
        pad-right = <6>;
    };

    ui_tab_label_style: ui_tab_label_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        text-font = <&ui_small_font>;
    };

    // A pill in the bottom bar: Back, and the Touchpad screen's Tilt toggle.
    ui_bar_key_style: ui_bar_key_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-color-hex = <UI_COLOR_TILE>;
        bg-opa = <255>;
        border-width = <0>;
        radius = <UI_RADIUS_FULL>;
        shadow-width = <0>;
        pad-left = <8>;
        pad-right = <8>;
    };

    // Tilt while on: lit like the current tab. This also clears the fill
    // LVGL's default theme gives a checked button.
    ui_toggle_checked_style: ui_toggle_checked_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-color-hex = <UI_COLOR_BLUE_TINT>;
        bg-opa = <255>;
        text-color-hex = <UI_COLOR_BLUE>;
    };

    ui_icon_style: ui_icon_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        text-font = <&ui_icon_font>;
    };

    ui_icon_tertiary_style: ui_icon_tertiary_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        text-font = <&ui_icon_font>;
        text-color-hex = <UI_COLOR_TEXT_TERTIARY>;
    };

    UI_ACCENT_STYLES(plain, UI_COLOR_TEXT, UI_COLOR_NEUTRAL_TINT)
    UI_ACCENT_STYLES(dim, UI_COLOR_TEXT_SECONDARY, UI_COLOR_NEUTRAL_TINT)
    UI_ACCENT_STYLES(blue, UI_COLOR_BLUE, UI_COLOR_BLUE_TINT)
    UI_ACCENT_STYLES(amber, UI_COLOR_AMBER, UI_COLOR_AMBER_TINT)
    UI_ACCENT_STYLES(violet, UI_COLOR_VIOLET, UI_COLOR_VIOLET_TINT)
    UI_ACCENT_STYLES(orange, UI_COLOR_ORANGE, UI_COLOR_ORANGE_TINT)
    UI_ACCENT_STYLES(cyan, UI_COLOR_CYAN, UI_COLOR_CYAN_TINT)
    UI_ACCENT_STYLES(green, UI_COLOR_GREEN, UI_COLOR_GREEN_TINT)
    // On a filled button: Clean all's icon in a lighter green circle, and
    // the app tiles' white icons.
    UI_ACCENT_STYLES(on_go, UI_COLOR_ON_GO, 0x2f8a56)
    UI_ACCENT_STYLES(on_brand, 0xffffff, 0xffffff)

    // Buttons are borderless surfaces a step lighter than the ground.
    ui_button_style: ui_button_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-color-hex = <UI_COLOR_TILE>;
        bg-opa = <255>;
        border-width = <0>;
        radius = <UI_RADIUS>;
        shadow-width = <0>;
        text-color-hex = <UI_COLOR_TEXT>;
    };

    // A pressed button lights up blue. LVGL's default theme also darkens it
    // by about 14% and grows it a little.
    ui_button_pressed_style: ui_button_pressed_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-color-hex = <UI_COLOR_TILE_PRESSED>;
        bg-grad-dir = "none";
        text-color-hex = <0xffffff>;
    };

    ui_tile_style: ui_tile_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        radius = <UI_RADIUS>;
        pad-top = <6>;
        pad-bottom = <7>;
        pad-left = <2>;
        pad-right = <2>;
    };

    // The main action on a vacuum's screen, filled green.
    ui_tile_go_style: ui_tile_go_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        radius = <UI_RADIUS>;
        pad-left = <0>;
        pad-right = <0>;
        bg-color-hex = <UI_COLOR_GO>;
        bg-grad-dir = "none";
        text-color-hex = <UI_COLOR_ON_GO>;
    };

    // The app tiles on the TV screen, in each app's brand colours.
    ui_tile_jellyfin_style: ui_tile_jellyfin_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        radius = <UI_RADIUS>;
        pad-top = <6>;
        pad-bottom = <7>;
        pad-left = <2>;
        pad-right = <2>;
        bg-color-hex = <0xaa5cc3>;
        bg-grad-color-hex = <0x00a4dc>;
        bg-grad-dir = "horizontal";
        text-color-hex = <0xffffff>;
    };

    ui_tile_youtube_style: ui_tile_youtube_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        radius = <UI_RADIUS>;
        pad-top = <6>;
        pad-bottom = <7>;
        pad-left = <2>;
        pad-right = <2>;
        bg-color-hex = <0xcc0000>;
        bg-grad-dir = "none";
        text-color-hex = <0xffffff>;
    };

    // The media keys: round, with Play/Pause filled.
    ui_round_key_style: ui_round_key_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        radius = <UI_RADIUS_FULL>;
    };

    ui_round_key_play_style: ui_round_key_play_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        radius = <UI_RADIUS_FULL>;
        bg-color-hex = <UI_COLOR_PLAY>;
        bg-grad-dir = "none";
        text-color-hex = <UI_COLOR_ON_PLAY>;
    };

    ui_text_key_style: ui_text_key_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        radius = <UI_RADIUS>;
        pad-left = <2>;
        pad-right = <2>;
        pad-top = <0>;
        pad-bottom = <0>;
    };

    ui_text_key_label_style: ui_text_key_label_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        text-align = "center";
        text-line-space = <(-2)>;
    };

    // The touchpad, filled so its edges are visible. It has no pressed look:
    // the host's pointer is the feedback.
    ui_touchpad_style: ui_touchpad_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-color-hex = <UI_COLOR_BAR>;
        bg-opa = <255>;
        border-width = <1>;
        border-color-hex = <UI_COLOR_TILE>;
        radius = <UI_RADIUS>;
    };

    // The faint how-to in the middle of the pad.
    ui_touchpad_hint_icon_style: ui_touchpad_hint_icon_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        text-font = <&ui_icon_font>;
        text-color-hex = <UI_COLOR_TEXT_TERTIARY>;
    };

    ui_touchpad_hint_style: ui_touchpad_hint_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        text-font = <&ui_small_font>;
        text-color-hex = <UI_COLOR_TEXT_TERTIARY>;
        text-align = "center";
        text-line-space = <3>;
    };

    ui_stepper_style: ui_stepper_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-color-hex = <UI_COLOR_TILE>;
        bg-opa = <255>;
        border-width = <0>;
        radius = <UI_RADIUS_FULL>;
        pad-top = <UI_STEPPER_PADDING>;
        pad-bottom = <UI_STEPPER_PADDING>;
        pad-left = <UI_STEPPER_PADDING>;
        pad-right = <UI_STEPPER_PADDING>;
    };

    ui_stepper_key_style: ui_stepper_key_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-color-hex = <UI_COLOR_NEUTRAL_TINT>;
        radius = <UI_RADIUS_FULL>;
    };

    ui_level_track_style: ui_level_track_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-color-hex = <UI_COLOR_TRACK>;
        bg-opa = <255>;
        radius = <UI_RADIUS_FULL>;
    };

    ui_level_fill_style: ui_level_fill_style {
        compatible = "dt-lvgl-style";
        #dt-lvgl-style-cells = <2>;
        bg-color-hex = <UI_COLOR_AMBER>;
        bg-opa = <255>;
        radius = <UI_RADIUS_FULL>;
    };

    ui_theme: ui_theme {
        compatible = "dt-lvgl-theme";
        primary-color-hex = <UI_COLOR_BLUE>;
        secondary-color-hex = <UI_COLOR_TILE>;
        dark;
        button-styles = <&ui_button_style DT_LVGL_PART_MAIN DT_LVGL_STATE_DEFAULT>,
                        <&ui_button_pressed_style DT_LVGL_PART_MAIN DT_LVGL_STATE_PRESSED>;
    };

    show_home: show_home {
        compatible = "dt-lvgl-action-screen-load";
        #dt-lvgl-action-cells = <1>;
        screen-id = "home";
    };

    show_lights: show_lights {
        compatible = "dt-lvgl-action-screen-load";
        #dt-lvgl-action-cells = <1>;
        screen-id = "lights";
    };

    show_tv: show_tv {
        compatible = "dt-lvgl-action-screen-load";
        #dt-lvgl-action-cells = <1>;
        screen-id = "tv";
    };

    show_more: show_more {
        compatible = "dt-lvgl-action-screen-load";
        #dt-lvgl-action-cells = <1>;
        screen-id = "more";
    };

    show_climate: show_climate {
        compatible = "dt-lvgl-action-screen-load";
        #dt-lvgl-action-cells = <1>;
        screen-id = "climate";
    };

    show_rosie: show_rosie {
        compatible = "dt-lvgl-action-screen-load";
        #dt-lvgl-action-cells = <1>;
        screen-id = "rosie";
    };

    show_chester: show_chester {
        compatible = "dt-lvgl-action-screen-load";
        #dt-lvgl-action-cells = <1>;
        screen-id = "chester";
    };

    show_touchpad: show_touchpad {
        compatible = "dt-lvgl-action-screen-load";
        #dt-lvgl-action-cells = <1>;
        screen-id = "touchpad";
    };

    ui: ui {
        compatible = "dt-lvgl";
        display = <&st7789v>;
        theme = <&ui_theme>;
        default-screen = "home";

        // The whole-house scenes, as three big rows.
        home_screen {
            compatible = "dt-lvgl-screen";
            id = "home";
            not-scrollable;
            styles = UI_STYLE(ui_screen_style);

            UI_STATUS_BAR(home, "Home")

            home_page {
                UI_PAGE_PROPS(UI_ONE_COLUMN,
                              <UI_CAPTION_HEIGHT UI_GRID_FR UI_GRID_FR UI_GRID_FR>)

                UI_CAPTION(home_scenes_caption, 0, 0, 1, "Scenes")
                UI_ACTION_ROW(scene_tv, 0, 1, 1, UI_ICON_TELEVISION_PLAY, violet,
                              "Watch TV", ui_tile_style)
                UI_ACTION_ROW(scene_on, 0, 2, 1, UI_ICON_LIGHTBULB_GROUP, amber,
                              "Lights on", ui_tile_style)
                UI_ACTION_ROW(scene_off, 0, 3, 1, UI_ICON_LIGHTBULB_GROUP_OFF, dim,
                              "Lights off", ui_tile_style)
            };

            UI_TAB_BAR(home, on, off, off, off)
        };

        // A column per room, with the hallway's one light across the
        // bottom.
        lights_screen {
            compatible = "dt-lvgl-screen";
            id = "lights";
            not-scrollable;
            styles = UI_STYLE(ui_screen_style);

            UI_STATUS_BAR(lights, "Lights")

            lights_page {
                UI_PAGE_PROPS(UI_TWO_COLUMNS,
                              <UI_CAPTION_HEIGHT UI_GRID_FR UI_GRID_FR UI_ROW_HEIGHT>)

                UI_COLUMN_CAPTION(lights_living_room_caption, 0, 0, "Living Room")
                UI_TILE(light_living_room_left, 0, 1, 1, UI_ICON_FLOOR_LAMP, amber, "Left", ui_tile_style)
                UI_TILE(light_living_room_right, 0, 2, 1, UI_ICON_FLOOR_LAMP, amber, "Right", ui_tile_style)

                UI_COLUMN_CAPTION(lights_kitchen_caption, 1, 0, "Kitchen")
                UI_TILE(light_kitchen_overhead, 1, 1, 1, UI_ICON_LIGHT_RECESSED, amber, "Overhead", ui_tile_style)
                UI_TILE(light_kitchen_table, 1, 2, 1, UI_ICON_CEILING_LIGHT, amber, "Table", ui_tile_style)

                UI_ACTION_ROW(light_hallway, 0, 3, 2, UI_ICON_LIGHTBULB, amber, "Hallway", ui_tile_style)
            };

            UI_TAB_BAR(lights, off, on, off, off)
        };

        // Power, volume and navigation are on the hardware keys.
        tv_screen {
            compatible = "dt-lvgl-screen";
            id = "tv";
            not-scrollable;
            styles = UI_STYLE(ui_screen_style);

            UI_STATUS_BAR(tv, "TV")

            tv_page {
                UI_PAGE_PROPS(UI_SIX_COLUMNS,
                              <UI_ROW_HEIGHT UI_GRID_FR UI_TV_MEDIA_HEIGHT UI_GRID_FR>)

                tv_mouse: tv_mouse {
                    compatible = "dt-lvgl-button";
                    id = "tv_mouse";
                    UI_CELL(0, 0, 6)
                    events = <&show_touchpad DT_LVGL_EVENT_CLICKED>;
                    styles = UI_STYLE(ui_tile_style);

                    UI_ROW_CONTENT(tv_mouse, UI_ICON_MOUSE, blue, "Mouse", ui_large_text_style)

                    tv_mouse_chevron {
                        compatible = "dt-lvgl-label";
                        text = UI_ICON_CHEVRON_RIGHT;
                        align = "right-mid";
                        align-x = <(-UI_ROW_CHEVRON_INSET)>;
                        styles = UI_STYLE(ui_icon_tertiary_style);
                    };
                };

                UI_TILE(tv_input, 0, 1, 3, UI_ICON_VIDEO_INPUT_HDMI, blue, "Input", ui_tile_style)
                UI_TILE(tv_mute, 3, 1, 3, UI_ICON_VOLUME_OFF, blue, "Mute", ui_tile_style)

                UI_ROUND_KEY(tv_rewind, 0, 2, 2, UI_ICON_REWIND, ui_round_key_style, ui_icon_style)
                UI_ROUND_KEY(tv_play_pause, 2, 2, 2, UI_ICON_PLAY_PAUSE, ui_round_key_play_style, ui_icon_style)
                UI_ROUND_KEY(tv_fast_forward, 4, 2, 2, UI_ICON_FAST_FORWARD, ui_round_key_style, ui_icon_style)

                UI_TILE(tv_jellyfin, 0, 3, 3, UI_ICON_PLAY_BOX_MULTIPLE, on_brand, "Jellyfin", ui_tile_jellyfin_style)
                UI_TILE(tv_youtube, 3, 3, 3, UI_ICON_YOUTUBE, on_brand, "YouTube", ui_tile_youtube_style)
            };

            UI_TAB_BAR(tv, off, off, on, off)
        };

        more_screen {
            compatible = "dt-lvgl-screen";
            id = "more";
            not-scrollable;
            styles = UI_STYLE(ui_screen_style);

            UI_STATUS_BAR(more, "More")

            more_page {
                UI_PAGE_PROPS(UI_TWO_COLUMNS,
                              <UI_ROW_HEIGHT UI_ROW_HEIGHT UI_ROW_HEIGHT
                               UI_STEPPER_HEIGHT>)

                UI_NAV_ROW(more_climate, 0, UI_ICON_THERMOSTAT, orange, "Climate", show_climate)
                UI_NAV_ROW(more_rosie, 1, UI_ICON_ROBOT_VACUUM, green, "Rosie", show_rosie)
                UI_NAV_ROW(more_chester, 2, UI_ICON_ROBOT_VACUUM, green, "Chester", show_chester)

                // The remote's own backlight, handled by src/brightness.c.
                UI_STEPPER(brightness, 3)
            };

            UI_TAB_BAR(more, off, off, off, on)
        };

        // The whole-home thermostat. Without a setpoint readout, Cooler and
        // Warmer step it rather than set it.
        climate_screen {
            compatible = "dt-lvgl-screen";
            id = "climate";
            not-scrollable;
            styles = UI_STYLE(ui_screen_style);

            UI_STATUS_BAR(climate, "Climate")

            climate_page {
                UI_PAGE_PROPS(UI_TWO_COLUMNS,
                              <UI_CAPTION_HEIGHT UI_GRID_FR UI_CAPTION_HEIGHT
                               UI_GRID_FR UI_GRID_FR>)

                UI_CAPTION(climate_temperature_caption, 0, 0, 2, "Temperature, 0.5\xc2\xb0 steps")
                UI_TILE(climate_cooler, 0, 1, 1, UI_ICON_MINUS, cyan, "Cooler", ui_tile_style)
                UI_TILE(climate_warmer, 1, 1, 1, UI_ICON_PLUS, orange, "Warmer", ui_tile_style)

                UI_CAPTION(climate_mode_caption, 0, 2, 2, "Mode")
                UI_TILE(climate_heat, 0, 3, 1, UI_ICON_FIRE, orange, "Heat", ui_tile_style)
                UI_TILE(climate_cool, 1, 3, 1, UI_ICON_SNOWFLAKE, cyan, "Cool", ui_tile_style)
                UI_TILE(climate_heat_cool, 0, 4, 1, UI_ICON_SUN_SNOWFLAKE_VARIANT, plain, "Heat/Cool", ui_tile_style)
                UI_TILE(climate_off, 1, 4, 1, UI_ICON_POWER, dim, "Off", ui_tile_style)
            };

            UI_BACK_BAR(climate, show_more)
        };

        UI_VACUUM_SCREEN(rosie, "Rosie",
                         master_bedroom, "Master", guest_bedroom, "Guest",
                         iris_bedroom, "Iris", marcus_bedroom, "Marcus")

        UI_VACUUM_SCREEN(chester, "Chester",
                         kitchen, "Kitchen", play_room, "Playroom",
                         living_room, "Living room", front_door, "Front door")

        // Moves the host's mouse pointer. src/touchpad.c reads touches that
        // start on touchpad_area while this screen is shown; LVGL itself
        // does nothing with them. While it is shown, the keymap's mouse
        // layer is on too, so the D-pad's centre clicks the left button
        // instead of pressing Enter.
        //
        // The bottom bar holds Back and Tilt, which also moves the pointer
        // as the remote turns (src/motion_pointer.c). Tilt stays on or off,
        // through sleep and power-off, until tapped again.
        touchpad_screen: touchpad_screen {
            compatible = "dt-lvgl-screen";
            id = "touchpad";
            not-scrollable;
            styles = UI_STYLE(ui_screen_style);

            UI_STATUS_BAR(touchpad, "Mouse")

            touchpad_page {
                UI_PAGE_PROPS(UI_ONE_COLUMN, <UI_GRID_FR>)

                touchpad_area: touchpad_area {
                    compatible = "dt-lvgl-container";
                    UI_CELL(0, 0, 1)
                    not-scrollable;
                    styles = UI_STYLE(ui_touchpad_style);

                    touchpad_hint_icon {
                        compatible = "dt-lvgl-label";
                        text = UI_ICON_GESTURE_TAP;
                        align = "center";
                        align-y = <(-30)>;
                        styles = UI_STYLE(ui_touchpad_hint_icon_style);
                    };

                    touchpad_hint {
                        compatible = "dt-lvgl-label";
                        text = "Slide to move\nTap to click\nHold to right-click";
                        align = "center";
                        align-y = <20>;
                        styles = UI_STYLE(ui_touchpad_hint_style);
                    };
                };
            };

            touchpad_bar {
                // Back is the arrow alone, in a circle: 45 px is
                // UI_NAVBAR_HEIGHT less ui_navbar_style's padding. That
                // leaves the rest of the bar to Tilt, so both keys have
                // room around their content.
                UI_NAVBAR_PROPS(<45 UI_GRID_FR>, ui_key_bar_style)

                touchpad_back {
                    compatible = "dt-lvgl-button";
                    grid-cell = <0 0>;
                    grid-align-self-x = "stretch";
                    grid-align-self-y = "stretch";
                    events = <&show_tv DT_LVGL_EVENT_CLICKED>;
                    styles = UI_STYLE(ui_bar_key_style);

                    touchpad_back_icon {
                        compatible = "dt-lvgl-label";
                        text = UI_ICON_ARROW_LEFT;
                        align = "center";
                        styles = UI_STYLE(ui_icon_style);
                    };
                };

                // Checked while tilt is on. src/motion_pointer.c sets the
                // saved state at boot and swaps the icon to match.
                touchpad_motion_toggle: touchpad_motion_toggle {
                    compatible = "dt-lvgl-button";
                    id = "touchpad_motion_toggle";
                    grid-cell = <1 0>;
                    grid-align-self-x = "stretch";
                    grid-align-self-y = "stretch";
                    checkable;
                    styles = <&ui_bar_key_style DT_LVGL_PART_MAIN DT_LVGL_STATE_DEFAULT>,
                             <&ui_toggle_checked_style DT_LVGL_PART_MAIN DT_LVGL_STATE_CHECKED>;

                    // The icon and label are centred as a pair, with 6 px
                    // between them. The offsets assume "Tilt" is 25 px wide
                    // in ui_large_font.
                    touchpad_motion_icon: touchpad_motion_icon {
                        compatible = "dt-lvgl-label";
                        text = UI_ICON_TOGGLE_SWITCH_OFF_OUTLINE;
                        align = "center";
                        align-x = <(-15)>;
                        styles = UI_STYLE(ui_icon_style);
                    };

                    touchpad_motion_label {
                        compatible = "dt-lvgl-label";
                        text = "Tilt";
                        align = "center";
                        align-x = <16>;
                        styles = UI_STYLE(ui_large_text_style);
                    };
                };
            };
        };
    };

    UI_BATTERY_STATUS(home)
    UI_BATTERY_STATUS(lights)
    UI_BATTERY_STATUS(tv)
    UI_BATTERY_STATUS(more)
    UI_BATTERY_STATUS(climate)
    UI_BATTERY_STATUS(rosie)
    UI_BATTERY_STATUS(chester)
    UI_BATTERY_STATUS(touchpad)
};

/ {
    zephyr,user {
        // src/bthome.c sends a press of each of these buttons to Home
        // Assistant as the number at the same position in
        // bthome-button-numbers. Numbers come in a block per screen, with
        // room to add buttons without renumbering the others;
        // home_assistant/bthome_buttons.yaml lists them all.
        bthome-buttons =
            // Lights and the scenes on Home, 1-19. 12 was the Evening scene
            // and is left unused so automations written for the old numbers
            // still match.
            <&light_living_room_left &light_living_room_right
             &light_kitchen_overhead &light_kitchen_table &light_hallway
             &scene_tv &scene_on &scene_off>,
            // TV, 20-39. Jellyfin and YouTube were hardware keys and kept
            // their numbers when they moved here.
            <&tv_jellyfin &tv_youtube &tv_input &tv_mute
             &tv_rewind &tv_play_pause &tv_fast_forward>,
            // Climate, 40-49
            <&climate_cooler &climate_warmer
             &climate_heat &climate_cool &climate_heat_cool &climate_off>,
            // Rosie, 50-69
            <&rosie_clean_all &rosie_pause &rosie_go_home
             &rosie_master_bedroom &rosie_guest_bedroom
             &rosie_iris_bedroom &rosie_marcus_bedroom>,
            // Chester, 70-89
            <&chester_clean_all &chester_pause &chester_go_home
             &chester_kitchen &chester_play_room
             &chester_living_room &chester_front_door>;
        bthome-button-numbers =
            <1 2 3 4 5 10 11 13>,
            <20 21 22 23 24 25 26>,
            <40 41 42 43 44 45>,
            <50 51 52 53 54 55 56>,
            <70 71 72 73 74 75 76>;

        // src/ui_status.c dims each screen's copy of the wireless icon until
        // the wireless link is up.
        ui-wireless-icons = <&home_wireless_icon &lights_wireless_icon &tv_wireless_icon
                             &more_wireless_icon &climate_wireless_icon
                             &rosie_wireless_icon &chester_wireless_icon
                             &touchpad_wireless_icon>;
    };
};
